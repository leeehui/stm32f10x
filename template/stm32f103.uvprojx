# Keil uVision project stm32f103.uvprojx, settings and files
target stm32f103 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin -o D:\STM32\F103\template\Objects\stm32f103.bin  D:\STM32\F103\template\Objects\stm32f103.axf
  c flags: Optim=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Src;.\Src;.\Src\App;.\Src\Bsp\ws2812;.\Src\Bsp\led;.\Src\Bsp\systick;.\Src\Bsp\usart;.\Src\App\CANopenNode;.\Src\App\CANopenNode\stack;.\Src\App\CANopenNode\stack\STM32f103;.\Src\Bsp\can;.\Src\Bsp\key;.\Src\Bsp\delay;.\Src\App\OeacnWave;.\Src\Bsp\idwg;.\Src\Bsp\timer;.\Src\Bsp\uniqueID
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_hd_vl.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Bsp
    ./Src/Bsp/ws2812/: light_ws2812_cortex.c
    ./Src/Bsp/systick/: bsp_SysTick.c
    ./Src/Bsp/usart/: bsp_debug_usart.c bsp_usart1.c bsp_usart.c
    ./Src/Bsp/can/: bsp_can.c
    ./Src/Bsp/key/: bsp_key.c
    ./Src/Bsp/delay/: bsp_delay.c
    ./Src/Bsp/idwg/: bsp_iwdg.c
    ./Src/Bsp/timer/: bsp_timer.c
    ./Src/Bsp/uniqueID/: bsp_unique_id.c
  group App
    ./Src/: main.c system_stm32f10x.c stm32f10x_it.c
    ./Src/App/OeacnWave/: ocean_wave.c
  group CanOpenNode
    ./Src/App/CANopenNode/: CANopen.c
    ./Src/App/CANopenNode/stack/: CO_Emergency.c CO_HBconsumer.c CO_NMT_Heartbeat.c CO_PDO.c CO_SDO.c CO_SDOmaster.c CO_SYNC.c CO_trace.c crc16-ccitt.c
    ./Src/App/CANopenNode/stack/STM32f103/: CO_driver.c CO_OD.c
